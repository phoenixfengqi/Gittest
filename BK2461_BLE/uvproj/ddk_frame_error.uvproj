# Keil uVision project ddk_frame_error.uvproj, settings and files
target Target 1 (MCS-51)
  device: Flip8051 Cyclone Dolphin
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: ddk_fram +hex
  AfterMake: .\GenTXT.BAT
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../src/: driver_uart.c main.c STARTUP.A51 patches.c driver_rf.c common.c timer.c
  group lib
    ../src/: BLE_boardcast.h BLE_boardcast_V01.LIB
